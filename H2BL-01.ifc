Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView], RevitIdentifiers [ContentGUID: , VersionGUID: 6cd2785f-895f-4a59-8bd9-d6bf06c3a2a2, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Coordinate condivise]
File name: H2BL-01.ifc
Time: 2025-10-19T12:45:08+01:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.80.30 (ITA) - IFC 23.4.1.0

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Altro - Categoria: Informazioni sul progetto

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Altro - Categoria: Informazioni sul progetto

# IfcBuildingStorey: Livello:Livello 1, Livello 1
LongName: Livello 1; Elevation: 0 mm
Altro - Categoria: Livelli; Famiglia: Livello; Famiglia e tipo: Livello: Livello 1; ID tipo: 1899; Tipo: Livello 1
Vincoli - Quota altimetrica: 0 mm
Quote - Altezza di calcolo: 0 mm
Dati identità - Nome: Livello 1; Piano edificio: yes; Strutturale: no
Altro(Type) - Categoria: Livelli; Nome famiglia: Livello
Vincoli(Type) - Base quota altimetrica: Punto base progetto
Grafica(Type) - Colore: 0; Modello di linea: Solido; Simbolo a estremità 1 per default: no; Simbolo a estremità 2 per default: yes; Spessore di linea: 1
Dati identità(Type) - Nome del tipo: Livello 1

# IfcRailing: H2BL-01_R23:H2BL-01_R23, H2BL-01_R23:H2BL-01_R23:15933
In: Livello 1
Type - Material: <Unnamed>, Metal, wood
Type - Altro - Categoria: Ringhiere: Supporti; Nome famiglia: H2BL-01_R23
Type - Costruzione - Altezza: 125 mm
Type - Dati identità - Acciaio CAM Strade: conforme; altezza lama (cm): 83; altezza tot (cm): 83; ASI: 0.9; CAD layer: n.a.; certificato art 14 comma 22: TOCUSTOMIZE; certificato CE: TOCUSTOMIZE; certificato di corretta posa: TOCUSTOMIZE; Classe: H2; classe intrusione del veicolo: VI6; classe larghezza di lavoro: W5; cordolo: n.a.; Costo: 257; deflessione dinamica (m): 1.5; Descrizione: (colore); documentazione integrativa (url): TOCUSTOMIZE; DOP: TOCUSTOMIZE; DSM: RiderPro-MRS-02; EPD: sì; GWP totale cradle to gate: 27.01 kgCO2eq/m; infissione (m): 1; interasse (m): 2; intrusione del veicolo (m): 1.9; larghezza di lavoro (m): 1.7; larghezza max (cm): 36; lavorazione aggiuntiva: TOCUSTOMIZE; Legno CAM Strade: CoC PEFC; livello di severità: A; lunghezza minima (m): 90; manuale di installazione: TOCUSTOMIZE; Materiale: Acciaio S355J0WP e Legno lamellare GL24H; Modello: H2BL-01; N° Certificato CE: CPR/0491/3154; Nome del tipo: H2BL-01_R23; Norma di riferimento: EN 1317-2 e EN1317-5; Prezzo di Capitolato: 257; Prodotto: Barriera di sicurezza stradale; Produttore: Margaritelli Road Safety; progressiva finale: TOCUSTOMIZE; progressiva iniziale: TOCUSTOMIZE; resoconti di prova: TOCUSTOMIZE; supporto: rilevato; testata su arginello: no; Tipologia: H2 Bordo Laterale; Unità di Misura: m; URL: https://margaritelli-rs.com/it/products/h2bl-01/; URL (certificati CE. DOP. manuali. schede tecniche. schemi): https://margaritelli-rs.com/it/products/h2bl-01/
Type - Pset_ManufacturerTypeInformation - Manufacturer: Margaritelli Road Safety
Pset_QuantityTakeOff - Reference: H2BL-01_R23
Pset_RailingCommon - Reference: H2BL-01_R23; IsExternal: no
Altro - Famiglia: H2BL-01_R23; Famiglia e tipo: H2BL-01_R23: H2BL-01_R23; ID tipo: 15917; Tipo: H2BL-01_R23
Vincoli - Gioco mano: 0 mm; Host: Livello : Livello 1; Livello: Livello 1; Offset da host: 0 mm; Sposta con gli elementi più vicini: no
Quote - Area: 10.9896 m2; Volume: 0.312199 m3
Dati identità - Basement: yes; Bordo_Dx: yes; Bordo_Sx: yes
